# IAR project BiosensorScript.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM350 AnalogDevices ADuCM350
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: ADI_SYSTEM_CLOCK_TRANSITION
  ICCARM.CCIncludePath2: ..\..\ADuCM350BBCZ - SDK\Eval-ADUCM350EBZ\inc; ..\..\ADuCM350BBCZ - SDK\Eval-ADUCM350EBZ\inc\config; ..\..\ADuCM350BBCZ - SDK\Eval-ADUCM350EBZ\examples; C:\Program Files\IAR Systems\Embedded Workbench 9.2\arm\src\flashloader\NXP\FlashQN9080\chip_qn908x\cmsis
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BiosensorScript.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: Readme.txt
  group Driver Sources
    ../../ADuCM350BBCZ - SDK/Eval-ADUCM350EBZ/src/: afe.c afe_lib.c dma.c gpio.c uart.c wdt.c
  group Main
    ../: BiosensorScript.c
    ../../ADuCM350BBCZ - SDK/Eval-ADUCM350EBZ/examples/AmperometricMeasurement/: PinMux.c
    ../../ADuCM350BBCZ - SDK/Eval-ADUCM350EBZ/examples/: test_common.c
  group System Sources
    ../../ADuCM350BBCZ - SDK/Eval-ADUCM350EBZ/src/: startup.c system.c
