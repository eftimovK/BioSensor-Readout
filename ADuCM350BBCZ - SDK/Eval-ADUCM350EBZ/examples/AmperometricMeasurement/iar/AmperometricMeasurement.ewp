# IAR project AmperometricMeasurement.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM350 AnalogDevices ADuCM350
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: ADI_DEBUG; ADI_SYSTEM_CLOCK_TRANSITION
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\inc\; ..\..\..\inc\config; ..\..\..\examples\; C:\Program Files\IAR Systems\Embedded Workbench 9.2\arm\src\flashloader\NXP\FlashQN9080\chip_qn908x\cmsis
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: AmperometricMeasurement.bin
  ILINK.IlinkOutputFile: AmperometricMeasurement.out
  ILINK.IlinkKeepSymbols: __checksum0; __checksum1; __parity0; __parity1
  ILINK.IlinkExtraOptions: --keep __checksum; --place_holder __checksum0,4,.checksum0,4; --place_holder __checksum1,4,.checksum1,4; --place_holder __parity0,0x1F00,.parity0,4; --place_holder __parity1,0x0F80,.parity1,4
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: ADI_SYSTEM_CLOCK_TRANSITION
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\..\inc; ..\..\..\inc\config
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  group (top)
    ../: Readme.txt
  group Driver Sources
    ../../../src/: afe.c afe_lib.c dma.c gpio.c uart.c wdt.c
  group System Sources
    ../../../src/: startup.c system.c
  group Test Sources
    ../: AmperometricMeasurement.c PinMux.c
    ../../: test_common.c
