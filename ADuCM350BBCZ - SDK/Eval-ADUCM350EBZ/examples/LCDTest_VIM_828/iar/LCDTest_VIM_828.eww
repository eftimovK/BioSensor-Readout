<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\LCDTest_VIM_828.ewp</path>
  </project>
  <batchBuild/>
</workspace>


