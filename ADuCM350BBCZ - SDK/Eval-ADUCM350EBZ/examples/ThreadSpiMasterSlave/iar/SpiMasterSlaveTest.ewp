# IAR project SpiMasterSlaveTest.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADUCM350BBCZ AnalogDevices ADUCM350BBCZ
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ADI_DEBUG; _USING_UCOS_II_; RELOCATE_IVT
  ICCARM.CCIncludePath2: ..\.; ..\..\.; ..\..\..\inc; ..\..\..\inc\config; ..\..\..\osal\uCOS-II\Ports; ..\..\..\osal\uCOS-II\Source; $_MICRIUM_DIR_$\uCOS-II\Source; $_MICRIUM_DIR_$\uCOS-II\Ports\ARM-Cortex-M3\CMSIS\IAR; $_MICRIUM_DIR_$\uC-CPU; $_MICRIUM_DIR_$\uC-CPU\ARM-Cortex-M3\IAR; $_MICRIUM_DIR_$\uC-CPU\Cfg\Template; $_MICRIUM_DIR_$\uC-LIB; $_MICRIUM_DIR_$\uC-LIB\Cfg\Template
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SpiMasterSlaveTest.srec
  postbuild: "..\..\..\tools\IElfTool\Debug_Win32_9\ielftool.exe" --fill 0xFF;0x0-0x5ffff --parity __parity0:0x1F00,even:0x00000000:L;0x0-0x3dfff --parity __parity1:0x0F80,even:0x00040000:L;0x40000-0x5efff --checksum __checksum0+0:4,crc32:LiR,0xffffffff;0x0-0x3fff7 --checksum __checksum0+4:4,crc32:Li,0xffffffff;0x0-0x3fff7 --checksum __checksum1+0:4,crc32:LiR,0xffffffff;0x40000-0x5fff7 --checksum __checksum1+4:4,crc32:Li,0xffffffff;0x40000-0x5fff7 "$TARGET_PATH$" "$TARGET_PATH$"
  ILINK.IlinkOutputFile: SpiMasterSlaveTest.out
  ILINK.IlinkKeepSymbols: __checksum0; __checksum1; __parity0; __parity1
  ILINK.IlinkExtraOptions: --keep __checksum; --place_holder __checksum0,4,.checksum0,4; --place_holder __checksum1,4,.checksum1,4; --place_holder __parity0,0x1F00,.parity0,4; --place_holder __parity1,0x0F80,.parity1,4
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _USING_UCOS_II_; NDEBUG; RELOCATE_IVT
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ../: readme.txt
  group App
    ../: app_cfg.h app_hooks.c os_cfg.h pinmux.c SpiMaster.c SpiMasterSlave.c SpiMasterSlave.h SpiSlave.c
    ../../: test_common.c
  group Driver Source
    ../../../src/: adi_int.c adi_nvic.c dma.c gpio.c spi.c uart.c wdt.c
  group libOSAL/Ports
    ../../../osal/uCOS-II/Ports/: adi_osal_arch.h adi_osal_arch_c.c adi_osal_arch_int_table.c adi_osal_arch_internal.h adi_osal_ucos2_arch_c.c
  group libOSAL/Source
    ../../../osal/uCOS-II/Source/: adi_osal.h adi_osal_ucos2.c adi_osal_ucos2_critical.c adi_osal_ucos2_event.c adi_osal_ucos2_init.c adi_osal_ucos2_message.c adi_osal_ucos2_mutex.c adi_osal_ucos2_rtl_lock.c adi_osal_ucos2_sem.c adi_osal_ucos2_timing.c app_cfg.h os_cfg.h osal_common.h osal_ucos.h version.h
  group SystemSources
    ../../../src/: startup.c system.c
  group uC-CPU
    $_MICRIUM_DIR_$/uC-CPU/: cpu_core.c
  group uC-CPU/ARM-Cortex-M3/IAR
    $_MICRIUM_DIR_$/uC-CPU/ARM-Cortex-M3/IAR/: cpu_a.asm cpu_c.c
  group uC-LIB
    $_MICRIUM_DIR_$/uC-LIB/: lib_mem.c lib_str.c
  group uCOS-II/Ports/ARM-Cortex-M3/CMSIS/IAR
    $_MICRIUM_DIR_$/uCOS-II/Ports/ARM-Cortex-M3/CMSIS/IAR/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uCOS-II/Source
    $_MICRIUM_DIR_$/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
