# IAR project ThreadTest.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADUCM350BBCZ AnalogDevices ADUCM350BBCZ
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ADI_DEBUG; _USING_UCOS_II_; RELOCATE_IVT
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\..\inc; ..\..\..\inc\config; $_MICRIUM_DIR_$\uCOS-II\Source; $_MICRIUM_DIR_$\uCOS-II\Ports\ARM-Cortex-M3\CMSIS\IAR; $_MICRIUM_DIR_$\uC-CPU; $_MICRIUM_DIR_$\uC-CPU\ARM-Cortex-M3\IAR; $_MICRIUM_DIR_$\uC-CPU\Cfg\Template; $_MICRIUM_DIR_$\uC-LIB; $_MICRIUM_DIR_$\uC-LIB\Cfg\Template
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  postbuild: "..\..\..\tools\IElfTool\Debug_Win32_9\ielftool.exe" --fill 0xFF;0x0-0x5ffff --parity __parity0:0x1F00,even:0x00000000:L;0x0-0x3dfff --parity __parity1:0x0F80,even:0x00040000:L;0x40000-0x5efff --checksum __checksum0+0:4,crc32:LiR,0xffffffff;0x0-0x3fff7 --checksum __checksum0+4:4,crc32:Li,0xffffffff;0x0-0x3fff7 --checksum __checksum1+0:4,crc32:LiR,0xffffffff;0x40000-0x5fff7 --checksum __checksum1+4:4,crc32:Li,0xffffffff;0x40000-0x5fff7 "$TARGET_PATH$" "$TARGET_PATH$"
  ILINK.IlinkOutputFile: ThreadTest.out
  ILINK.IlinkKeepSymbols: __checksum0; __checksum1; __parity0; __parity1
  ILINK.IlinkExtraOptions: --keep __checksum; --place_holder __checksum0,4,.checksum0,4; --place_holder __checksum1,4,.checksum1,4; --place_holder __parity0,0x1F00,.parity0,4; --place_holder __parity1,0x0F80,.parity1,4
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _USING_UCOS_II_; NDEBUG
  group (top)
    ../: readme.txt
  group App
    ../: app_hooks.c ThreadTest.c
  group SystemSources
    ../../../src/: startup.c system.c
  group uC-CPU
    $_MICRIUM_DIR_$/uC-CPU/: cpu_core.c
  group uC-CPU/ARM-Cortex-M3/IAR
    $_MICRIUM_DIR_$/uC-CPU/ARM-Cortex-M3/IAR/: cpu_a.asm cpu_c.c
  group uC-LIB
    $_MICRIUM_DIR_$/uC-LIB/: lib_mem.c lib_str.c
  group uCOS-II/Ports/ARM-Cortex-M3/CMSIS/IAR
    $_MICRIUM_DIR_$/uCOS-II/Ports/ARM-Cortex-M3/CMSIS/IAR/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uCOS-II/Source
    $_MICRIUM_DIR_$/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
