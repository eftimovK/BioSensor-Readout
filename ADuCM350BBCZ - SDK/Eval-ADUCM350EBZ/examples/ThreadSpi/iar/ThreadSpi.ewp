# IAR project ThreadSpi.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADUCM350BBCZ AnalogDevices ADUCM350BBCZ
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ADI_DEBUG; RELOCATE_IVT
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\..\inc; ..\..\..\inc\config; ..\..\..\osal\noos\Source; ..\..\..\osal\uCOS-II\Ports; ..\..\..\osal\uCOS-II\Source; $_MICRIUM_DIR_$\uCOS-II\Source; $_MICRIUM_DIR_$\uCOS-II\Ports\ARM-Cortex-M3\Generic\IAR; $_MICRIUM_DIR_$\uC-CPU\ARM-Cortex-M3\IAR; $_MICRIUM_DIR_$\uC-CPU; $_MICRIUM_DIR_$\uC-CPU\Cfg\Template; $_MICRIUM_DIR_$\uC-LIB
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  postbuild: "..\..\..\tools\IElfTool\Debug_Win32_9\ielftool.exe" --fill 0xFF;0x0-0x5ffff --parity __parity0:0x1F00,even:0x00000000:L;0x0-0x3dfff --parity __parity1:0x0F80,even:0x00040000:L;0x40000-0x5efff --checksum __checksum0+0:4,crc32:LiR,0xffffffff;0x0-0x3fff7 --checksum __checksum0+4:4,crc32:Li,0xffffffff;0x0-0x3fff7 --checksum __checksum1+0:4,crc32:LiR,0xffffffff;0x40000-0x5fff7 --checksum __checksum1+4:4,crc32:Li,0xffffffff;0x40000-0x5fff7 "$TARGET_PATH$" "$TARGET_PATH$"
  ILINK.IlinkOutputFile: ThreadSpi.out
  ILINK.IlinkKeepSymbols: __checksum0; __checksum1; __parity0; __parity1
  ILINK.IlinkExtraOptions: --keep __checksum; --place_holder __checksum0,4,.checksum0,4; --place_holder __checksum1,4,.checksum1,4; --place_holder __parity0,0x1F00,.parity0,4; --place_holder __parity1,0x0F80,.parity1,4
  ILINK.IlinkAdditionalLibs: ..\..\..\osal\uCOS-II\Lib\iar\Debug\Exe\libosal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkAdditionalLibs: ..\..\..\osal\uCOS-II\Lib\iar\Release\Exe\libosal.a
  group (top)
    ../: Readme.txt
  group Application
    ../: app_hooks.c pinmux.c ThreadSpi.c
    ../../: test_common.c
  group Driver Sources
    ../../../src/: adi_int.c adi_nvic.c dma.c gpio.c spi.c wdt.c
  group System Sources
    ../../../src/: startup.c system.c
  group uC-CPU
    $_MICRIUM_DIR_$/uC-CPU/: cpu_core.c
  group uC-CPU/IAR
    $_MICRIUM_DIR_$/uC-CPU/ARM-Cortex-M3/IAR/: cpu_a.asm cpu_c.c
  group uCOS-II/Ports/CMSIS/IAR
    $_MICRIUM_DIR_$/uCOS-II/Ports/ARM-Cortex-M3/CMSIS/IAR/: os_cpu_a.asm os_cpu_c.c
  group uCOS-II/Source
    $_MICRIUM_DIR_$/uCOS-II/Source/: os_core.c os_dbg_r.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS-II/TLS/IAR
    $_MICRIUM_DIR_$/uCOS-II/TLS/IAR/: os_tls.c
