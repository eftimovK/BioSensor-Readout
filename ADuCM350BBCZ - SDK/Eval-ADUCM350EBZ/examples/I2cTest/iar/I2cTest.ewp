# IAR project I2cTest.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADUCM350BBCZ AnalogDevices ADUCM350BBCZ
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ADI_DEBUG; ADI_I2C_LOOPBACK
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\..\inc; ..\..\..\inc\config
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  postbuild: "..\..\..\tools\IElfTool\Debug_Win32_9\ielftool.exe" --fill 0xFF;0x0-0x5ffff --parity __parity0:0x1F00,even:0x00000000:L;0x0-0x3dfff --parity __parity1:0x0F80,even:0x00040000:L;0x40000-0x5efff --checksum __checksum0+0:4,crc32:LiR,0xffffffff;0x0-0x3fff7 --checksum __checksum0+4:4,crc32:Li,0xffffffff;0x0-0x3fff7 --checksum __checksum1+0:4,crc32:LiR,0xffffffff;0x40000-0x5fff7 --checksum __checksum1+4:4,crc32:Li,0xffffffff;0x40000-0x5fff7 "$TARGET_PATH$" "$TARGET_PATH$"
  ILINK.IlinkOutputFile: I2cTest.out
  ILINK.IlinkKeepSymbols: __checksum0; __checksum1; __parity0; __parity1
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\AnalogDevices\ADuCM350BBCZ.icf
  ILINK.IlinkExtraOptions: --keep __checksum; --place_holder __checksum0,4,.checksum0,4; --place_holder __checksum1,4,.checksum1,4; --place_holder __parity0,0x1F00,.parity0,4; --place_holder __parity1,0x0F80,.parity1,4
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: ADI_I2C_LOOPBACK
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group (top)
    ../: Readme.txt
  group Driver Sources
    ../../../src/: dma.c gpio.c i2c.c uart.c wdt.c
  group System Sources
    ../../../src/: startup.c system.c
  group Test Sources
    ../: i2c_pinmux.c I2cTest.c
    ../../: test_common.c
