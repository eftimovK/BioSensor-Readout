<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\osal\uCOS-II\Lib\iar\libosal.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\msc.ewp</path>
  </project>
  <batchBuild/>
</workspace>


