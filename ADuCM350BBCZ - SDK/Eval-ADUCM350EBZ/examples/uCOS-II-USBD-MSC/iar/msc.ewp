# IAR project msc.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: ADUCM350BBCZ AnalogDevices ADUCM350BBCZ
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; NADI_DEBUG; _USING_UCOS_II_; RELOCATE_IVT; ADI_SYSTEM_CLOCK_TRANSITION
  ICCARM.CCIncludePath2: ..; ..\..\..\usb\inc\; ..\..\..\inc; ..\..\..\src; ..\..\..\examples; ..\..\..\inc\config; ..\..\..\usb\inc; ..\..\..\osal\uCOS-II\Source; ..\..\..\osal\uCOS-II\Ports; ..\..\..\usb\inc\drivers\usb\controller\device; ..\..\..\usb\ucusb\Ports\Drivers\ADI; ..\..\..\usb\ucusb\Ports\Drivers\ADI\BSP; $_MICRIUM_DIR_$\uC-USB-Device-V4\App\Device\OS\uCOS-II; $_MICRIUM_DIR_$\uC-USB-Device-V4\Class\MSC; $_MICRIUM_DIR_$\uC-USB-Device-V4\Class\MSC\Storage\RAMDisk; $_MICRIUM_DIR_$\uC-USB-Device-V4\Class\Test; $_MICRIUM_DIR_$\uC-USB-Device-V4\Source; $_MICRIUM_DIR_$\uC-CPU; $_MICRIUM_DIR_$\uC-CPU\ARM-Cortex-M3\IAR; $_MICRIUM_DIR_$\uC-CPU\Cfg\Template; $_MICRIUM_DIR_$\uC-LIB; $_MICRIUM_DIR_$\uCOS-II\Ports\ARM-Cortex-M3\CMSIS\IAR; $_MICRIUM_DIR_$\uCOS-II\Source
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  postbuild: "..\..\..\tools\IElfTool\Debug_Win32_9\ielftool.exe" --fill 0xFF;0x0-0x5ffff --parity __parity0:0x1F00,even:0x00000000:L;0x0-0x3dfff --parity __parity1:0x0F80,even:0x00040000:L;0x40000-0x5efff --checksum __checksum0+0:4,crc32:LiR,0xffffffff;0x0-0x3fff7 --checksum __checksum0+4:4,crc32:Li,0xffffffff;0x0-0x3fff7 --checksum __checksum1+0:4,crc32:LiR,0xffffffff;0x40000-0x5fff7 --checksum __checksum1+4:4,crc32:Li,0xffffffff;0x40000-0x5fff7 "$TARGET_PATH$" "$TARGET_PATH$"
  ILINK.IlinkOutputFile: msc.out
  ILINK.IlinkKeepSymbols: __checksum0; __checksum1; __parity0; __parity1
  ILINK.IlinkExtraOptions: --keep __checksum; --place_holder __checksum0,4,.checksum0,4; --place_holder __checksum1,4,.checksum1,4; --place_holder __parity0,0x1F00,.parity0,4; --place_holder __parity1,0x0F80,.parity1,4
  ILINK.IlinkAdditionalLibs: ..\..\..\osal\uCOS-II\Lib\iar\Debug\Exe\libosal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; ADI_DEBUG; _USING_UCOS_II_; RELOCATE_IVT; ADI_SYSTEM_CLOCK_TRANSITION
  ICCARM.CCIncludePath2: ..; ..\..\..\usb\inc\; ..\..\..\inc; ..\..\..\src; ..\..\..\examples; ..\..\..\inc\config; ..\..\..\osal\uCOS-II\Source; ..\..\..\osal\uCOS-II\Ports; ..\..\..\usb\inc; ..\..\..\usb\inc\drivers\usb\controller\device; ..\..\..\usb\ucusb\Ports\Drivers\ADI; ..\..\..\usb\ucusb\Ports\Drivers\ADI\BSP; $_MICRIUM_DIR_$\uC-USB-Device-V4\App\Device\OS\uCOS-II; $_MICRIUM_DIR_$\uC-USB-Device-V4\Class\MSC; $_MICRIUM_DIR_$\uC-USB-Device-V4\Class\MSC\Storage\RAMDisk; $_MICRIUM_DIR_$\uC-USB-Device-V4\Class\Test; $_MICRIUM_DIR_$\uC-USB-Device-V4\Source; $_MICRIUM_DIR_$\uC-CPU; $_MICRIUM_DIR_$\uC-CPU\ARM-Cortex-M3\IAR; $_MICRIUM_DIR_$\uC-CPU\Cfg\Template; $_MICRIUM_DIR_$\uC-LIB; $_MICRIUM_DIR_$\uCOS-II\Ports\ARM-Cortex-M3\CMSIS\IAR; $_MICRIUM_DIR_$\uCOS-II\Source
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: phdc.srec
  group (top)
    ../: readme.txt
  group Application
    ../: app.c app_hooks.c app_usbd.c app_usbd_msc.c usbd_dev_cfg.c
  group DriverSources
    ../../../src/: gpio.c wdt.c
  group DriverSources/USB/ADI
    ../../../usb/ucusb/Ports/Drivers/ADI/: usbd_drv_adi.c
  group DriverSources/USB/ADI/SSLDD20/musbmhdrc
    ../../../usb/src/drivers/usb/controller/musbmhdrc/: adi_usbd_musbmhdrc.c
  group DriverSources/USB/BSP
    ../../../usb/ucusb/Ports/Drivers/ADI/BSP/: usbd_bsp_dev.c
  group SystemSources
    ../../../src/: adi_int.c adi_nvic.c startup.c system.c
    ../../: test_common.c
  group uC-CPU
    $_MICRIUM_DIR_$/uC-CPU/ARM-Cortex-M3/IAR/: cpu_c.c
    $_MICRIUM_DIR_$/uC-CPU/: cpu_core.c
  group uC-CPU/ARM-Cortex-M3/IAR
    $_MICRIUM_DIR_$/uC-CPU/ARM-Cortex-M3/IAR/: cpu_a.asm
  group uC-LIB
    $_MICRIUM_DIR_$/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group uC-LIB/Ports/ARM-Cortex-M3/IAR
    $_MICRIUM_DIR_$/uC-LIB/Ports/ARM-Cortex-M3/IAR/: lib_mem_a.asm
  group uC-USB-Device-V4/Class/MSC
    $_MICRIUM_DIR_$/uC-USB-Device-V4/Class/MSC/: usbd_msc.c usbd_scsi.c
  group uC-USB-Device-V4/Class/MSC/OS/uCOS-II
    $_MICRIUM_DIR_$/uC-USB-Device-V4/Class/MSC/OS/uCOS-II/: usbd_msc_os.c
  group uC-USB-Device-V4/Class/MSC/Storage/RAMDisk
    $_MICRIUM_DIR_$/uC-USB-Device-V4/Class/MSC/Storage/RAMDisk/: usbd_storage.c
  group uC-USB-Device-V4/OS/uCOS-II
    $_MICRIUM_DIR_$/uC-USB-Device-V4/OS/uCOS-II/: usbd_os.c
  group uC-USB-Device-V4/Source
    $_MICRIUM_DIR_$/uC-USB-Device-V4/Source/: usbd_core.c usbd_ep.c
  group uCOS-II/Ports/ARM-Cortex-M3/CMSIS/IAR
    $_MICRIUM_DIR_$/uCOS-II/Ports/ARM-Cortex-M3/CMSIS/IAR/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uCOS-II/Source
    $_MICRIUM_DIR_$/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
